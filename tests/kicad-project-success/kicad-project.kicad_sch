File: tests/kicad-project-success/kicad-project.kicad_sch (KiCad schematic)
At the start: 4 parts, among them SW101 SW_Push

Commit message: Updated project
Parts:
- U101: value ~ -> (none)
